EXTRA_OECONF_class-native_append = " --enable-targets=x86_64-pep"
EXTRA_OECONF_append = " --enable-targets=x86_64-pep"
