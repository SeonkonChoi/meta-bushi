
FILES_${PN}-dev += " ${libdir}/cairo"
